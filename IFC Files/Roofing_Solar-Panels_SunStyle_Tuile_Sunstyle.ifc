Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-31T19:58:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 19:58:07 2023 * Host: E7270 * Database: C:\Users\GOODLU~1\AppData\Local\Temp\f6eb3f9f-7fa0-42ba-b934-946579097e53\a1e2ba3b-f759-4428-929f-16fb21eeb684\ifc * Database version: 5507 * Database creation date: Fri Mar 31 19:58:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 19:58:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 19:58:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -1, -58, -789672; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 2
LongName: Level 2; Elevation: 3000 mm
Pset_AirSideSystemInformation - Name: Level 2
Pset_ProductRequirements - Name: Level 2; Category: Levels

# IfcBuildingElementProxy: Tuile Sunstyle - Noir, Roofing_Solar-Panels_SunStyle_Tuile_Sunstyle:Tuile Sunstyle - Noir:414327
In: Level 2
Type - Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Caoutchouc - Sunstyle - Noir
Type - Pset_BuildingElementProxyCommon - Reference: Tuile Sunstyle - Noir
Type - Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Tuile Sunstyle - Noir
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: <unnamed>

# IfcDistributionPort, Port_414327
Description: Flow; FlowDirection: SOURCEANDSINK
