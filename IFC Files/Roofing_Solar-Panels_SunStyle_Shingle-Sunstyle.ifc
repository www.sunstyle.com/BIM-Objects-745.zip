Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-31T20:04:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 20:04:21 2023 * Host: E7270 * Database: C:\Users\GOODLU~1\AppData\Local\Temp\f6eb3f9f-7fa0-42ba-b934-946579097e53\42d181b9-da8f-4efd-bb81-fb9d129bb63e\ifc * Database version: 5507 * Database creation date: Fri Mar 31 20:04:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 20:04:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 20:04:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -1, -58, -789672; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 2
LongName: Level 2; Elevation: 3000 mm
Pset_AirSideSystemInformation - Name: Level 2
Pset_ProductRequirements - Name: Level 2; Category: Levels

# IfcBuildingElementProxy: Shingle Sunstyle - Black, Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle:Shingle Sunstyle - Black:414062
In: Level 2
Type - Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Black, Steel - Sunstyle - Clear Coated Steel
Type - Pset_BuildingElementProxyCommon - Reference: Shingle Sunstyle - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Shingle Sunstyle - Black
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: <unnamed>

# IfcDistributionPort, Port_414062
Description: Flow; FlowDirection: SOURCEANDSINK
