Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-31T13:49:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 13:49:17 2023 * Host: E7270 * Database: C:\Users\GOODLU~1\AppData\Local\Temp\b1170706-e8fa-46ba-94f5-8ef82c9c555d\0efa0d9b-4ebc-4533-83b2-ab3518cf00b5\ifc * Database version: 5507 * Database creation date: Fri Mar 31 13:49:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 13:49:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 13:49:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: Shingle Customisable - Black, SunStyle_Shingle-Customisable:Shingle Customisable - Black:346387
In: Level 1
Type - Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Black
Type - Pset_BuildingElementProxyCommon - Reference: Shingle Customisable - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Shingle Customisable - Black
Pset_BuildingElementProxyCommon - sets with these values: 2
