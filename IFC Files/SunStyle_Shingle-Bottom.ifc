Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-28T14:02:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 28 14:02:21 2023 * Host: E7270 * Database: C:\Users\GOODLU~1\AppData\Local\Temp\3b0d7998-34e0-4bb5-8308-4b6e8ab42ae1\68de2e85-9eff-44e7-8dca-43594d958f37\ifc * Database version: 5507 * Database creation date: Tue Mar 28 14:02:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 28 14:02:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 28 14:02:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: Shingle Bottom - Silver, SunStyle_Shingle-Bottom:Shingle Bottom - Silver:346392
In: Level 1
Type - Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Silver
Type - Pset_BuildingElementProxyCommon - Reference: Shingle Bottom - Silver
Type - Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Shingle Bottom - Silver
Pset_BuildingElementProxyCommon - sets with these values: 2
