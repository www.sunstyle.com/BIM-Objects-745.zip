Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-31T14:35:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 14:35:48 2023 * Host: E7270 * Database: C:\Users\GOODLU~1\AppData\Local\Temp\b1170706-e8fa-46ba-94f5-8ef82c9c555d\83f00559-a06a-4fd5-86d6-38d97c88937b\ifc * Database version: 5507 * Database creation date: Fri Mar 31 14:35:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 14:35:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 14:35:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -1, -58, -789672; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 2
LongName: Level 2; Elevation: 3000 mm
Pset_AirSideSystemInformation - Name: Level 2
Pset_ProductRequirements - Name: Level 2; Category: Levels

# IfcBuildingElementProxy: Non PV Shingle - Black, SunStyle_Non-PV-Shingle:Non PV Shingle - Black:414050
In: Level 2
Type - Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Black
Type - Pset_BuildingElementProxyCommon - Reference: Non PV Shingle - Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Non PV Shingle - Black
Pset_BuildingElementProxyCommon - sets with these values: 2
